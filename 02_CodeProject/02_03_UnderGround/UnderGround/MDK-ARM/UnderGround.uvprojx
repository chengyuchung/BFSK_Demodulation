# Keil uVision project UnderGround.uvprojx, settings and files
target UnderGround (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: UnderGround +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,ARM_MATH_CM4
  c misc: --fpu=FPv4-SP
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../APP/app_main;../../APP/app_sensor;../../APP/app_task;../../APP/app_node_fsm;../../BSW/bsw_ds18b20;../../BSW/bsw_log;../../BSW/bsw_bmp280;../../BSW/bsw_ad9833;../../BSW/bsw_adc_ringbuf;../../BSW/bsw_relay;../../BSW/bsw_node_id;../../MCAL/mcal_clock;../../MCAL/mcal_gpio;../../MCAL/mcal_dma;../../MCAL/mcal_adc;../../MCAL/mcal_timer;../../MCAL/mcal_spi;../../MCAL/mcal_uart;../../MCAL/mcal_i2c;../../MCAL/mcal_ow;../../BSW/bsw_bfsk_demod;../../BSW/bsw_proto;../../BSW/bsw_led;../../BSW/bsw_freq_storage;../../BSW/bsw_version;..\..\APP\app_frame_handler;..\..\BSW\bsw_bfsk_mod;..\..\APP\app_freq_detector;..\..\BSW\bsw_freq_analyzer
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group MCAL
    ../../MCAL/mcal_gpio/: mcal_gpio.c
    ../../MCAL/mcal_timer/: mcal_timer.c
    ../../MCAL/mcal_uart/: mcal_uart.c
    ../../MCAL/mcal_adc/: mcal_adc.c
    ../../MCAL/mcal_ow/: mcal_ow.c
    ../../MCAL/mcal_clock/: mcal_clock.c
    ../../MCAL/mcal_dma/: mcal_dma.c
    ../../MCAL/mcal_spi/: mcal_spi.c
    ../../MCAL/mcal_i2c/: mcal_i2c.c
  group BSW
    ../../BSW/bsw_ds18b20/: bsw_ds18b20.c
    ../../BSW/bsw_log/: bsw_log.c
    ../../BSW/bsw_bmp280/: bsw_bmp280.c
    ../../BSW/bsw_ad9833/: bsw_ad9833.c
    ../../BSW/bsw_relay/: bsw_relay.c
    ../../BSW/bsw_adc_ringbuf/: bsw_adc_ringbuf.c
    ../../BSW/bsw_node_id/: bsw_node_id.c
    ../../BSW/bsw_bfsk_demod/: bsw_bfsk_demod.c
    ../../BSW/bsw_proto/: bsw_proto.c
    ../../BSW/bsw_led/: bsw_led.c
    ../../BSW/bsw_freq_storage/: bsw_freq_storage.c
    ../../BSW/bsw_version/: bsw_version.c
    ../../BSW/bsw_bfsk_mod/: bsw_bfsk_mod.c
    ../../BSW/bsw_freq_analyzer/: bsw_freq_analyzer.c
  group APP
    ../../APP/app_main/: app_main.c
    ../../APP/app_sensor/: app_sensor.c
    ../../APP/app_task/: app_task.c
    ../../APP/app_node_fsm/: app_node_fsm.c
    ../../APP/app_frame_handler/: app_frame_handler.c
    ../../APP/app_freq_detector/: app_freq_detector.c
software components: CMSIS:CORE 4.3.0
